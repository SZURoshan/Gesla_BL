# Keil uVision project Gesla.uvprojx, settings and files
target Gesla (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Gesla +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\CORE;..\APP;..\APP\inc;..\BSP\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group APP
    ../APP/: main.c sysinit.c
    ../APP/src/: flash_control.c
  group BSP
    ../BSP/src/: uart_db.c led.c
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_wwdg.c stm32f10x_tim.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s stm32f10x_it.c system_stm32f10x.c
